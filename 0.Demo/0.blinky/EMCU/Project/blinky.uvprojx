# Keil uVision project blinky.uvprojx, settings and files
target Target (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: blinky +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Libraries\CMSIS\CoreSupport\arm;..\Libraries\CMSIS\DeviceSupport\system;..\Libraries\StdPeriph_Driver\Includes;..\User
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../Libraries/CMSIS/DeviceSupport/startup/arm/: startup_gw1ns4c.s
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/system/: system_gw1ns4c.c
    ../Libraries/CMSIS/CoreSupport/arm/: core_cm3.c
  group FWLIB
    ../Libraries/StdPeriph_Driver/Sources/: gw1ns4c_gpio.c gw1ns4c_i2c.c gw1ns4c_misc.c gw1ns4c_rtc.c gw1ns4c_spi.c gw1ns4c_syscon.c gw1ns4c_timer.c gw1ns4c_uart.c gw1ns4c_wdog.c
  group USER
    ../User/: gw1ns4c_it.c main.c delay.c
